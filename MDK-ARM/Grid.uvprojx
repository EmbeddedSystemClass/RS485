# Keil uVision project Grid.uvprojx, settings and files
target Grid (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F030C8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: Grid +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F030x8
  c include: ../Inc;                       ../Drivers/STM32F0xx_HAL_Driver/Inc;                       ../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;                       ../Middlewares/Third_Party/FreeRTOS/Source/include;                       ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;                       ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM0;                       ../Drivers/CMSIS/Device/ST/STM32F0xx/Include;                       ../Drivers/CMSIS/Include;                       ..\FreeModbus\modbus\include;                       ..\FreeModbus\port;                       ..\FreeModbus\modbus\rtu;                       ..\FreeModbus\modbus\ascii;                       ..\FreeModbus\modbus\tcp
  asm include: ..\\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application/MDK-ARM
    ./: startup_stm32f030x8.s
  group Application/User
    ../Src/: main.c gpio.c freertos.c tim.c usart.c stm32f0xx_it.c stm32f0xx_hal_msp.c stm32f0xx_hal_timebase_tim.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_dma.c stm32f0xx_hal_cortex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM0/: port.c
  group FreeModbus/PORT
    ../FreeModbus/port/: portevent.c portserial.c porttimer.c
    ./: port.c
  group FreeModbus/ModBus
    ../FreeModbus/modbus/ascii/: mbascii.c
    ../FreeModbus/modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ../FreeModbus/modbus/rtu/: mbcrc.c mbrtu.c
    ../FreeModbus/modbus/tcp/: mbtcp.c
    ../FreeModbus/modbus/: mb.c
